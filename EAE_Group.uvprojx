# Keil uVision project EAE_Group.uvprojx, settings and files
target Main Target (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: M032SE3AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.20
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: template
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  c include: .\Library\StdDriver\inc;.\Library\Device\Nuvoton\M031\Include;.\Library\CMSIS\Include;.\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_M031Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ./Library/Device/Nuvoton/M031/Source/: system_M031Series.c
    ./Library/Device/Nuvoton/M031/Source/ARM/: startup_M031Series.s
  group Library
    ./Library/StdDriver/src/: clk.c retarget.c gpio.c timer.c
  group src
    ./src/: main.c button.c led.c softTimer.c utils.c eventDriven.c
  group inc
    ./inc/: button.h led.h main.h softTimer.h utils.h eventDriven.h
software components: CMSIS:CORE 5.5.0
